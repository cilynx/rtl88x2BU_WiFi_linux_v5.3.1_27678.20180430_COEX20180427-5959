## Kconfig
```kconfig
config RTL8822BU
	tristate "Realtek 8822B USB WiFi"
	depends on USB
	---help---
	  Driver for the RTL8822BU USB Wi-Fi adapter.
```
